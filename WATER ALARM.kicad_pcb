# Repository nripesh135-wq/kicad-water-alarm

File README.md:

# Water Leak Alarm

A simple water leak detector board designed in KiCad 9.0. It uses an N-channel MOSFET to trigger an active buzzer when water bridges the sensor contacts.

## How it works
The circuit relies on a basic voltage divider. The gate of the 2N7000 MOSFET is tied to ground through a massive 10MΩ pull-down resistor. This keeps the gate at 0V so the buzzer stays off, and it prevents false alarms from ambient static in the air.

When a drop of water (which naturally conducts a little bit of electricity) touches the two sensor wires, it creates a bridge between the 9V power supply and the MOSFET gate. Because the water's resistance is much lower than 10MΩ, the 9V side pulls the gate voltage high. This turns on the MOSFET, completes the circuit to ground, and sounds the buzzer.

## Project Images

### Schematic

### Board Layout

### 3D Render

## Parts List
* Q1: 2N7000 (N-Channel MOSFET)
* R1: 10MΩ Resistor (Pull-down)
* R2: 6.8KΩ Resistor
* C1: 1nF Capacitor (Noise filtering)
* BZ1: Active Buzzer
* D1: Standard 5mm LED
* Hardware: Screw terminal (J2) and DC Barrel Jack (J1)

## KiCad design WATER ALARM.kicad_pcb

Board: 2 copper layers, 30.1 x 36.6 mm, 8 parts (0 on the bottom side), 5 nets.

Parts:
BZ1: Buzzer; Buzzer_D30mm_H20mm_P15mm__668-1652-ND__AI-3035-TT-12V-R
C1: 1nF; C_Disc_D3.0mm_W1.6mm_P2.50mm
D1: LED_Small_Filled; LED_D5.0mm
J1: Jack-DC; BarrelJack_GCT_DCJ200-10-A_Horizontal
J2: Screw_Terminal_01x02; TerminalBlock_Phoenix_PT-1,5-2-5.0-H_1x02_P5.00mm_Horizontal
Q1: 2N7000; TO-92_Inline
R1: 10M; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
R2: 6.8K; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal

Connections:
/Gate: C1.1, J2.2, Q1.2 (G), R1.1
GND: C1.2, J1.2, Q1.1 (S), R1.2, R2.2
unnamed: BZ1.2 (-), Q1.3 (D)
unnamed: D1.1 (K), R2.1
VCC: BZ1.1 (+), D1.2 (A), J1.1, J2.1
